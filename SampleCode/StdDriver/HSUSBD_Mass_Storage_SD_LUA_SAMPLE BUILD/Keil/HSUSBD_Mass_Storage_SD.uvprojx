# Keil uVision project HSUSBD_Mass_Storage_SD.uvprojx, settings and files
target HSUSBD_Mass_Storage_SD (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: HSUSBD_Mass_Storage_SD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --c99
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\ThirdParty\FreeRTOS;..\..\HSUSBD_Mass_Storage_SD;..\..\..\..\ThirdParty\FatFs\source;..\LUA
  asm define: Stack_Size=0xb000 Heap_Size=0xb000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M460/Source/: system_M460.c
    ../../../../Library/Device/Nuvoton/M460/Source/ARM/: startup_M460.s
  group User
    ../: main.c descriptors.c massstorage.c lua_isp.c LUA_FATFS_FREERTOS_LIB.lib
